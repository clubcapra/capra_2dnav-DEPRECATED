Commit message: param adjustments for mapping tests

File: models/capra6/capra6-real.urdf (robot description, URDF)
Before this commit: robot capra6, 2 links, 1 joints
Joints:
- joint joint1: origin xyz=0.6 0 0.4 rpy=0 0 0 -> xyz=0.36 0 0.44 rpy=0 0 0
